options:
  parameters:
    author: student
    generate_options: qt_gui
    id: FM_RDS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '66000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: samp_rate*5
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1'
    max_dev: 75e3
    quad_rate: samp_rate*5
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0_0_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0_0_1_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0_0_0_1_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '13500'
    low_cutoff_freq: '10500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '52000'
    low_cutoff_freq: '24000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_3_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '14000'
    low_cutoff_freq: '11000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_3_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '38500'
    low_cutoff_freq: '37500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_3_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '59000'
    low_cutoff_freq: '55000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_3_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Asus\Downloads\Thalapathy_Kacheri_-_Anirudh_Ravichander.mp3
    repeat: 'True'
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'False'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '4'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '14000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '14000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" Original [53,54,69]  "'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"dark blue"'
    fc: '0'
    fftsize: '1024'
    label1: '''L'''
    label2: '''R'''
    name: '"Stereo [53,54,69] "'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" L+R "'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" L-R  [53,54,69]  "'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" DSB SC [53,54,69] "'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" Transmitted [53,54,69] "'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"R [53,54,69] "'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"L [53,54,69] "'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Received [53,54,69] "'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Reterieved [53,54,69] "'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Original [53,54,69] "'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Transmitted [53,54,69] "'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '" Retereived [53,54,69] "'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" Original [53,54,69] "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '''L'''
    name: '"L [53,54,69] "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" L+R [53,54,69]  "'
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '''L'''
    name: '"R [53,54,69]  "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" L-R [53,54,69]  "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DSB SC [53,54,69] "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" Transmitted [53,54,69] "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"R [53,54,69] "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" L [53,54,69] "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0_0_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '" Received [53,54,69]  "'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0_0_1_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Retereived [53,54,69] "'
    type: float
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '2000'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '6'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_1_1_2
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '6'
    type: fff
  states: {state: disabled}
- name: rds_decoder_0
  id: rds_decoder
  parameters:
    debug: 'True'
    log: 'True'
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 89.8e6
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: WDR 3
    pty: '14'
    pty_locale: '0'
    radiotext: GNU Radio <3
    ta: 'False'
    tp: 'True'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '1187'
    differential: 'False'
    f_offset: '0'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}

connections:
- [analog_fm_preemph_0, '0', analog_wfm_tx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_2, '1']
- [analog_wfm_rcv_0, '0', band_pass_filter_3, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_3_1_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_xx_1_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_xx_1_0, '1']
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0_1_0_0_1_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0_1_0_0_1_0_0, '0']
- [analog_wfm_tx_0, '0', analog_wfm_rcv_0, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0, '0', blocks_sub_xx_0, '1']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '1']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [band_pass_filter_3, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_3_0, '0', blocks_add_xx_3_0, '1']
- [band_pass_filter_3_0, '0', qtgui_freq_sink_x_0_1_0_0_1, '0']
- [band_pass_filter_3_0, '0', qtgui_waterfall_sink_x_0_1_0_0_1, '0']
- [band_pass_filter_3_0, '0', rational_resampler_xxx_0_1_1_0, '0']
- [band_pass_filter_3_1, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_3_1_0, '0', satellites_bpsk_demodulator_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_add_xx_1, '0', analog_fm_preemph_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0_1_0_0_0, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_1, '0', qtgui_waterfall_sink_x_0_1_0_0_0, '0']
- [blocks_add_xx_3, '0', low_pass_filter_2, '0']
- [blocks_add_xx_3_0, '0', qtgui_freq_sink_x_0_1_0_0_1_1, '0']
- [blocks_add_xx_3_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_add_xx_3_0, '0', qtgui_waterfall_sink_x_0_1_0_0_1_1, '0']
- [blocks_add_xx_3_0, '0', rational_resampler_xxx_0_1_1_2, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_float_to_char_0, '0', rds_decoder_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_1, '2']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_add_xx_1, '3']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_1_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0_1_0_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_1_0, '0']
- [blocks_multiply_xx_1_0, '0', band_pass_filter_3_1, '0']
- [blocks_multiply_xx_2, '0', blocks_complex_to_real_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_sub_xx_0, '0', qtgui_waterfall_sink_x_0_1_0, '0']
- [blocks_sub_xx_1, '0', band_pass_filter_3_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0_0, '0']
- [digital_psk_mod_0, '0', blocks_multiply_xx_2, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [low_pass_filter_1, '0', blocks_add_xx_3, '0']
- [low_pass_filter_1, '0', blocks_sub_xx_1, '0']
- [low_pass_filter_1_0, '0', blocks_add_xx_3, '1']
- [low_pass_filter_1_0, '0', blocks_sub_xx_1, '1']
- [low_pass_filter_2, '0', blocks_add_xx_3_0, '0']
- [low_pass_filter_2, '0', qtgui_freq_sink_x_0_1_0_0_1_0, '0']
- [low_pass_filter_2, '0', qtgui_waterfall_sink_x_0_1_0_0_1_0, '0']
- [low_pass_filter_2, '0', rational_resampler_xxx_0_1_1, '0']
- [rational_resampler_xxx_0_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0_1_1, '0', audio_sink_0_0_0_0_1, '0']
- [rational_resampler_xxx_0_1_1_0, '0', audio_sink_0_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_1_1_2, '0', audio_sink_0_0_0_0_1_1, '0']
- [rds_encoder_0, '0', digital_psk_mod_0, '0']
- [satellites_bpsk_demodulator_0, '0', blocks_float_to_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
